# Keil uVision project Computer_Sim.uvprojx, settings and files
target Computer_Sim (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Computer_Sim +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_USB_OTG_FS,LV_CONF_INCLUDE_SIMPLE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../FreeRTOS/include;../FreeRTOS/portable/MemMang;../FreeRTOS/portable/RVDS/ARM_CM4F;../../Computer_Sim;../LCD;../USB/STM32_USB_HOST_Library/Class/HID/inc;../USB/STM32_USB_HOST_Library/Core/inc;../USB/STM32_USB_OTG_Driver/inc;../USB/USB_APP;../lvgl;../lvgl/examples/porting;../lvgl/src;../SRAM;../lvgl/demos;../lvgl/demos/widgets;../SDIO;../FATFS/src;../FATFS/exfuns;../MALLOC;../W25QXX;../SPI;../USMART;..\usart;..\I2S;..\WM8978;..\IIC;..\RTC;..\LED;..\KEY;..\XMRAM;..\UI;..\TPAD;..\AUDIOCODEC\wav;..\Audio;..\TEXT
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Inc/: FreeRTOSConfig.h sys.h stm32f4xx_hal_conf.h
    ../: freertos_demo.c freertos_demo.h delay.c delay.h
    ../Core/Src/: sys.c main.c gpio.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group FreeRTOS/Portable
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Core
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group USB
    ../USB/USB_APP/: usb_bsp.c usbh_usr.c usb_stubs.c
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
    ../USB/STM32_USB_HOST_Library/Class/HID/src/: usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c
    ../USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group lvgl/example
    ../lvgl/examples/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c lv_port_lcd_stm32_template.c
    ../lvgl/examples/porting/osal/: lv_example_osal.c
  group lvgl/src
    ../lvgl/src/: lv_init.c
    ../lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
  group lvgl/src/core
    ../lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
  group lvgl/src/debugging
    ../lvgl/src/debugging/vg_lite_tvg/: vg_lite_matrix.c
    ../lvgl/src/debugging/test/: lv_test_display.c lv_test_fs.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../lvgl/src/debugging/sysmon/: lv_sysmon.c
    ../lvgl/src/debugging/monkey/: lv_monkey.c
  group lvgl/src/display
    ../lvgl/src/display/: lv_display.c
  group lvgl/src/draw
    ../lvgl/src/draw/: lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c lv_draw_3d.c lv_draw.c
    ../lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_bitmap_font_cache.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../lvgl/src/draw/sw/blend/riscv_v/: lv_draw_sw_blend_riscv_v_to_rgb888.c
    ../lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../lvgl/src/draw/snapshot/: lv_snapshot.c
    ../lvgl/src/draw/sdl/: lv_draw_sdl.c
    ../lvgl/src/draw/opengles/: lv_draw_opengles.c
    ../lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_nema_gfx_path.c
    ../lvgl/src/draw/nanovg/: lv_draw_nanovg.c lv_draw_nanovg_3d.c lv_draw_nanovg_arc.c lv_draw_nanovg_border.c lv_draw_nanovg_box_shadow.c lv_draw_nanovg_fill.c lv_draw_nanovg_grad.c lv_draw_nanovg_image.c lv_draw_nanovg_label.c lv_draw_nanovg_layer.c lv_draw_nanovg_line.c lv_draw_nanovg_mask_rect.c lv_draw_nanovg_triangle.c lv_draw_nanovg_vector.c lv_nanovg_fbo_cache.c lv_nanovg_image_cache.c lv_nanovg_utils.c
    ../lvgl/src/draw/eve/: lv_draw_eve.c lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_eve.c
    ../lvgl/src/draw/espressif/ppa/: lv_draw_ppa.c lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c
    ../lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
  group lvgl/src/drivers
    ../lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    ../lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    ../lvgl/src/drivers/wayland/: lv_wayland.c lv_wl_egl_backend.c lv_wl_g2d_backend.c lv_wl_keyboard.c lv_wl_pointer.c lv_wl_seat.c lv_wl_shm_backend.c lv_wl_touch.c lv_wl_window.c lv_wl_xdg_shell.c
    ../lvgl/src/drivers/uefi/: lv_uefi_context.c lv_uefi_display.c lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c
    ../lvgl/src/drivers/sdl/: lv_sdl_egl.c lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_sw.c lv_sdl_texture.c lv_sdl_window.c
    ../lvgl/src/drivers/qnx/: lv_qnx.c
    ../lvgl/src/drivers/opengles/: lv_opengles_debug.c lv_opengles_driver.c lv_opengles_egl.c lv_opengles_glfw.c lv_opengles_texture.c
    ../lvgl/src/drivers/opengles/opengl_shader/: lv_opengl_shader_manager.c lv_opengl_shader_program.c
    ../lvgl/src/drivers/opengles/glad/src/: egl.c gl.c gles2.c
    ../lvgl/src/drivers/opengles/assets/: lv_opengles_shader.c
    ../lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_mouse.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ../lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    ../lvgl/src/drivers/evdev/: lv_evdev.c
    ../lvgl/src/drivers/draw/eve/: lv_draw_eve_display.c
    ../lvgl/src/drivers/display/st7796/: lv_st7796.c
    ../lvgl/src/drivers/display/st7789/: lv_st7789.c
    ../lvgl/src/drivers/display/st7735/: lv_st7735.c
    ../lvgl/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    ../lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    ../lvgl/src/drivers/display/nxp_elcdif/: lv_nxp_elcdif.c
    ../lvgl/src/drivers/display/nv3007/: lv_nv3007.c
    ../lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ../lvgl/src/drivers/display/ili9341/: lv_ili9341.c
    ../lvgl/src/drivers/display/ft81x/: lv_ft81x.c
    ../lvgl/src/drivers/display/fb/: lv_linux_fbdev.c
    ../lvgl/src/drivers/display/drm/: lv_linux_drm.c lv_linux_drm_common.c lv_linux_drm_egl.c
  group lvgl/src/font
    ../lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../lvgl/src/font/imgfont/: lv_imgfont.c
    ../lvgl/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../lvgl/src/font/binfont_loader/: lv_binfont_loader.c
  group lvgl/src/indev
    ../lvgl/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group lvgl/src/layout
    ../lvgl/src/layouts/: lv_layout.c
    ../lvgl/src/layouts/grid/: lv_grid.c
    ../lvgl/src/layouts/flex/: lv_flex.c
  group lvgl/src/misc
    ../lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
  group lvgl/src/osal
    ../lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
  group lvgl/src/others
    ../lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../lvgl/src/others/translation/: lv_translation.c
  group lvgl/src/stdlib
    ../lvgl/src/stdlib/: lv_mem.c
    ../lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
  group lvgl/src/themes
    ../lvgl/src/themes/: lv_theme.c
    ../lvgl/src/themes/simple/: lv_theme_simple.c
    ../lvgl/src/themes/mono/: lv_theme_mono.c
    ../lvgl/src/themes/default/: lv_theme_default.c
  group lvgl/src/tick
    ../lvgl/src/tick/: lv_tick.c
  group lvgl/src/widgets
    ../lvgl/src/widgets/win/: lv_win.c
    ../lvgl/src/widgets/tileview/: lv_tileview.c
    ../lvgl/src/widgets/textarea/: lv_textarea.c
    ../lvgl/src/widgets/tabview/: lv_tabview.c
    ../lvgl/src/widgets/table/: lv_table.c
    ../lvgl/src/widgets/switch/: lv_switch.c
    ../lvgl/src/widgets/spinner/: lv_spinner.c
    ../lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../lvgl/src/widgets/span/: lv_span.c
    ../lvgl/src/widgets/slider/: lv_slider.c
    ../lvgl/src/widgets/scale/: lv_scale.c
    ../lvgl/src/widgets/roller/: lv_roller.c
    ../lvgl/src/widgets/property/: lv_animimage_properties.c lv_buttonmatrix_properties.c lv_arc_properties.c lv_bar_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../lvgl/src/widgets/menu/: lv_menu.c
    ../lvgl/src/widgets/lottie/: lv_lottie.c
    ../lvgl/src/widgets/list/: lv_list.c
    ../lvgl/src/widgets/line/: lv_line.c
    ../lvgl/src/widgets/led/: lv_led.c
    ../lvgl/src/widgets/label/: lv_label.c
    ../lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../lvgl/src/widgets/ime/: lv_ime_pinyin.c
    ../lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../lvgl/src/widgets/image/: lv_image.c
    ../lvgl/src/widgets/gif/: lv_gif.c
    ../lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../lvgl/src/widgets/chart/: lv_chart.c
    ../lvgl/src/widgets/canvas/: lv_canvas.c
    ../lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../lvgl/src/widgets/button/: lv_button.c
    ../lvgl/src/widgets/bar/: lv_bar.c
    ../lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../lvgl/src/widgets/arc/: lv_arc.c
    ../lvgl/src/widgets/animimage/: lv_animimage.c
    ../lvgl/src/widgets/3dtexture/: lv_3dtexture.c
  group lvgl
    ../lvgl/: lv_conf.h lv_version.h lvgl.h lvgl_private.h
  group BSP
    ../BSP/touch/: touch.c
  group LCD
    ../LCD/: lcd.c
  group SRAM
    ../SRAM/: sram.c
  group lvgl/demos
    ../lvgl/demos/: lv_demos.c
    ../lvgl/demos/widgets/: lv_demo_widgets.c lv_demo_widgets_analytics.c lv_demo_widgets_components.c lv_demo_widgets_profile.c lv_demo_widgets_shop.c
    ../lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
  group SD
    ../SDIO/: sdio_sdcard.c sdio_sdcard.h
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
    ../FATFS/exfuns/: exfuns.c fattester.c
  group Malloc
    ../MALLOC/: malloc.c malloc.h
  group W25QXX
    ../W25QXX/: w25qxx.c w25qxx.h
  group SPI
    ../SPI/: spi.c spi.h
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group usart
    ../usart/: usart.c usart.h
  group I2S
    ../I2S/: i2s.c i2s.h
  group WAV&WM8978
    ../WM8978/: wm8978.c wm8978.h
  group I2C
    ../IIC/: myiic.c myiic.h
  group LED
    ../LED/: led.c led.h
  group KEY
    ../KEY/: key.c key.h
  group RTC
    ../RTC/: rtc.c rtc.h
  group XMRAM
    ../XMRAM/: XMRAM.h XMRAM.lib
  group UI
    ../UI/: KeyboardInput.c KeyboardInput.h Password.c Password.h ScreenPower.c ScreenPower.h desktop.c desktop.h DesktopUI.c DesktopUI.h SystemSettings.c SystemSettings.h
  group TPAD
    ../TPAD/: tpad.c tpad.h
  group wavplay
    ../AUDIOCODEC/wav/: wavplay.c wavplay.h
  group Audio
    ../Audio/: audioplay.c audioplay.h
  group Text
    ../TEXT/: fontupd.c fontupd.h text.c text.h
software components: CMSIS:CORE 4.3.0
